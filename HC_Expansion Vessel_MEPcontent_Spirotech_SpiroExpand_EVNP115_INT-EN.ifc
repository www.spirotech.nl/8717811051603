Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115_INT-EN.ifc
Time: 2025-08-05T18:30:15+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115 -230_INT-EN:EVNP115, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115 -230_INT-EN:EVNP115:2066069
In: F00
Type - Material: Color RGB 040-040-040, Color RGB 168-168-168, Color RGB 251-203-029
Type - Other - Category: Mechanical Equipment; Connector Height: 105 mm; Diameter: 500 mm; Expansion Pipe Length: 240 mm; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115 -230_INT-EN; Height Logo: 113 mm; Leg 7-1: yes; Leg 8-1: no; Logo Radius: 250.5 mm; Nominal Diameter: 19 mm; Outer Diameter: 26.9 mm; Pressure Valve Position: 230 mm; Vassel 120-300: yes; Void Logo 1: 497 mm; Void Logo 2: 150 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19 mm; Height: 750 mm; Use Nominal Diameter: yes; Width: 500 mm
Type - Identity Data - Article Description: EVNP Expansion vessel for systems with buffer tanks - 155 ltr; Article Type: EVNP115; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: EVNP Expansion vessel for systems with buffer tanks - 155 ltr; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 23.13; GLN: 8717811000007; GTIN: 8717811051603; Manufacturer: Spirotech; Manufacturer Art. No.: EVNP115; Manufacturer URL: https://www.spirotech.com/8717811051603; MEPcontent Class: EXPANSIONVESSEL; Model: EVNP115; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EVNP115; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Grey: Color RGB 168-168-168; Yellow: Color RGB 251-203-029
Type - Mechanical - Max. Safety Temperature: 110 C; Standard Gas Pressure: 300000 Pa; Volume: 0.115 m3; Weight: 30 kg
Type - Text - Pipe Type Category: M561
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EVNP115; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EVNP115
Other - Expansion Pipe Height: 60 mm; Expansion Pipe Height 1: 73.45 mm; Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115 -230_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_EVNP115 -230_INT-EN: EVNP115; Type: EVNP115; Type Id: 2066053
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.788275 m2; Volume: 0.11587 m3
Identity Data - Mark: 4
Mechanical - Flow: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort, InPort_2066069_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE
